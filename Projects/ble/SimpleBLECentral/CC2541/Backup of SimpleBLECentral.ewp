# IAR project Backup of SimpleBLECentral.ewp, settings and files
configuration CC2541EM (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=TRUE; HAL_UART=TRUE; LCD_TO_UART; HAL_UART_DMA=1; HAL_UART_ISR=0; HCI_UART_BR=4; xADD_CC2590; HAL_KEY=FALSE
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\SimpleBLECentral\Source
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\..\common\cc2540\ti_51ew_cc2540b.xcl
configuration L-CC2541-OAD-ImgA (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: FEATURE_OAD; OAD_KEEP_NV_PAGES; FEATURE_OAD_BIM; HAL_IMAGE_A; INT_HEAP_LEN=3072; HALNODEBUG; OSAL_CBTIMER_NUM_TASKS=1; HAL_AES_DMA=TRUE; HAL_DMA=TRUE; xPOWER_SAVING; HAL_LCD=TRUE; HAL_UART=TRUE; LCD_TO_UART; HAL_UART_DMA=1; HAL_UART_ISR=0; HCI_UART_BR=4
  ICC8051.CCIncludePath2: ..\..\common; ..\..\..\..\Components\hal\include; ..\..\..\..\Components\hal\target\CC2540EB; ..\..\..\..\Components\osal\include; ..\..\..\..\Components\services\saddr; ..\..\..\..\Components\ble\include; ..\..\..\..\Components\ble\controller\phy; ..\..\..\..\Components\ble\controller\include; ..\..\..\..\Components\ble\hci; ..\..\..\..\Components\ble\host; ..\..\common\cc2540; ..\..\common\npi\npi_np; ..\..\Include; ..\..\Profiles\Roles; ..\..\Profiles\SimpleProfile; ..\..\Profiles\OAD
  ICC8051.CCOptLevel: 3
  postbuild: "..\..\common\cc2540\cc254x_ubl_pp.bat" "$PROJ_DIR$" "ProdUBL" "L-CC2541-OAD-ImgA\Exe\SimpleBLEPeripheral"
  XLINK.XclFile: ..\..\common\cc2540\cc254x_f256_imgA.xcl
  group APP
    ../Source/: order.c order.h OSAL_simpleBLECentral.c serial.c serial.h simpleBLECentral.c simpleBLECentral.h simpleBLECentral_Main.c
  group HAL/Common
    ../../../../Components/hal/common/: hal_drivers.c
  group HAL/Include
    ../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2540EB/Config
    ../../../../Components/hal/target/CC2540EB/: hal_board_cfg.h
  group HAL/Target/CC2540EB/Drivers
    ../../../../Components/hal/target/CC2540EB/: hal_adc.c hal_aes.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c hal_uart.c
  group HAL/Target/CC2540EB/Includes
    ../../../../Components/hal/target/CC2540EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group LIB
    ../../Libraries/CC2541DB/bin/: CC2541_BLE_cent.lib
    ../../Libraries/Common/bin/: CC254x_BLE_HCI_TL_None.lib
  group NPI
    ../../common/npi/npi_np/: npi.c NPI.h npi_spi.c npi_uart.c
  group OSAL
    ../../../../Components/ble/include/: bcomdef.h
    ../../../../Components/osal/common/: OSAL.c osal_bufmgr.c osal_cbtimer.c OSAL_ClockBLE.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../../../../Components/osal/mcu/cc2540/: osal_snv.c
  group PROFILES
    ../../Profiles/Roles/: central.c central.h gap.c gapbondmgr.c gapbondmgr.h
    ../../Include/: gapgattserver.h gattservapp.h
    ../../../../Components/ble/host/: gatt_uuid.c
    ../../Profiles/OAD/: oad.h oad_target.c oad_target.h
  group TOOLS
    ../../config/: buildComponents.cfg
    ./: buildConfig.cfg
    ../../common/cc2540/: OnBoard.c OnBoard.h
